
require zing-base.bb

IMAGE_INSTALL += "zing-kmod"
IMAGE_INSTALL += "zing-app"

